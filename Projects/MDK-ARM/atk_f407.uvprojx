# Keil uVision project atk_f407.uvprojx, settings and files
target BEEP (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\SYSTEM\delay;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\BEEP;..\..\Drivers;..\..\User;..\..\User\Hardware;..\..\User\Hardware\WM8978;..\..\User\Hardware\AUDIO;../../Middlewares/USB/STM32_USB_Device_Library/Core/Inc;../../Middlewares/USB/STM32_USB_Device_Library/Class/Inc;../../Middlewares/USB/USB_APP;../../Middlewares/FATFS;../../User/Hardware/SDIO;../../User/APP;../../User/Hardware/LCD;..\..\User\Hardware\KEY;..\..\User\Hardware\TOUCH
  asm include: ..\..\User\Hardware\KEY;..\..\User\Hardware\TOUCH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\atk_f407.sct
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../User/Hardware/: i2c_soft.c codec_detect.c
    ../../User/Hardware/WM8978/: wm8978.c
    ../../User/Hardware/AUDIO/: i2s_audio.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/BEEP/: beep.c
  group Readme
    ../../: readme.txt
  group Middlewares/USB
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/Src/: usbd_cdc.c
    ../../Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_cdc_if.c usb_device.c
  group User/APP
    ../../User/APP/: audio_source.c wav_probe.c cdc_ctrl.c
  group User/Hardware/LCD
    ../../User/Hardware/LCD/: lcd.c lcd_ui.c
  group User/Hardware/KEY
    ../../User/Hardware/KEY/: key.c
  group User/Hardware/TOUCH
    ../../User/Hardware/TOUCH/: tp.c
